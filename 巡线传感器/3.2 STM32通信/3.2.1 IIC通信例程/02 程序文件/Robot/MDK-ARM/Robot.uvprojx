# Keil uVision project Robot.uvprojx, settings and files
target Robot (6160000::V6.16::ARMCLANG)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: Robot +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=6 v6LangP=7 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Hiwonder/Peripherals/Inc;../Hiwonder;../Hiwonder/Portings/Inc;../Hiwonder/Arm/Inc;../Hiwonder/Middlewares/Inc;../Hiwonder/Chassis/Inc;../Hiwonder/Third_Party/U8g2
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dma.c i2c.c spi.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_i2c.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Hiwonder/Peripherals
    ../Hiwonder/Peripherals/Src/: led.c w25q64.c buzzer.c serial_servo.c adc_sample.c LineFollow.c
  group Hiwonder/Portings
    ../Hiwonder/Portings/Src/: led_porting.c ps2_porting.c app_porting.c
  group Hiwonder/Middleware
    ../Hiwonder/Middlewares/Src/: lwrb.c
  group Hiwonder/Arm
    ../Hiwonder/Arm/src/: robot_arm.c
software components: CMSIS:CORE 5.5.0, Compiler:Event Recorder 1.4.0, Compiler:I/O:STDOUT 1.2.0
